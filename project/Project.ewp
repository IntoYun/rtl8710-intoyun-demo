# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None; default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CONFIG_PLATFORM_8711B; __IEEE_LITTLE_ENDIAN
  ICCARM.CCDiagSuppress: Be006,Pa050,Pa039,Pa089,Pe014,Pe047,Pe068,Pe089,Pe167,Pe177,Pe186,Pe188,Pe375,Pe550,Pe550,Pe223,Pe549,Pe550
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\main\inc; ..\components\sdk-ameba\os\freertos; ..\components\sdk-ameba\os\freertos\freertos_v8.1.2\Source\include; ..\components\sdk-ameba\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM4F; ..\components\sdk-ameba\os\os_dep\include; ..\components\sdk-ameba\common\api\network\include; ..\components\sdk-ameba\common\api; ..\components\sdk-ameba\common\api\at_cmd; ..\components\sdk-ameba\common\api\platform; ..\components\sdk-ameba\common\api\wifi; ..\components\sdk-ameba\common\api\wifi\rtw_wpa_supplicant\src; ..\components\sdk-ameba\common\api\wifi\rtw_wowlan; ..\components\sdk-ameba\common\api\wifi\rtw_wpa_supplicant\wpa_supplicant; ..\components\sdk-ameba\common\application; ..\components\sdk-ameba\common\application\mqtt\MQTTClient; ..\components\sdk-ameba\common\application\mqtt\MQTTPacket; ..\components\sdk-ameba\common\example; ..\components\sdk-ameba\common\example\wlan_fast_connect; ..\components\sdk-ameba\common\drivers\modules; ..\components\sdk-ameba\common\drivers\sdio\realtek\sdio_host\inc; ..\components\sdk-ameba\common\drivers\inic\rtl8711b; ..\components\sdk-ameba\common\drivers\usb_class\device; ..\components\sdk-ameba\common\drivers\usb_class\device\class; ..\components\sdk-ameba\common\drivers\wlan\realtek\include; ..\components\sdk-ameba\common\drivers\wlan\realtek\src\osdep; ..\components\sdk-ameba\common\drivers\wlan\realtek\src\hci; ..\components\sdk-ameba\common\drivers\wlan\realtek\src\hal; ..\components\sdk-ameba\common\drivers\wlan\realtek\src\hal\rtl8711b; ..\components\sdk-ameba\common\drivers\wlan\realtek\src\hal\OUTSRC; ..\components\sdk-ameba\common\drivers\wlan\realtek\wlan_ram_map\rom; ..\components\sdk-ameba\common\network; ..\components\sdk-ameba\common\network\lwip\lwip_v1.4.1\port\realtek\freertos; ..\components\sdk-ameba\common\network\lwip\lwip_v1.4.1\src\include; ..\components\sdk-ameba\common\network\lwip\lwip_v1.4.1\src\include\lwip; ..\components\sdk-ameba\common\network\lwip\lwip_v1.4.1\src\include\ipv4; ..\components\sdk-ameba\common\network\lwip\lwip_v1.4.1\port\realtek; ..\components\sdk-ameba\common\network\ssl\polarssl-1.3.8\include; ..\components\sdk-ameba\common\network\ssl\ssl_ram_map\rom; ..\components\sdk-ameba\common\test; ..\components\sdk-ameba\common\utilities; ..\components\sdk-ameba\soc\realtek\8711b\app\monitor\include; ..\components\sdk-ameba\soc\realtek\8711b\cmsis; ..\components\sdk-ameba\soc\realtek\8711b\cmsis\device; ..\components\sdk-ameba\soc\realtek\8711b\fwlib; ..\components\sdk-ameba\soc\realtek\8711b\fwlib\include; ..\components\sdk-ameba\soc\realtek\8711b\fwlib\ram_lib\crypto; ..\components\sdk-ameba\soc\realtek\8711b\fwlib\rom_lib; ..\components\sdk-ameba\soc\realtek\8711b\swlib\os_dep\include; ..\components\sdk-ameba\soc\realtek\8711b\swlib\std_lib\include; ..\components\sdk-ameba\soc\realtek\8711b\swlib\std_lib\libc\include; ..\components\sdk-ameba\soc\realtek\8711b\swlib\std_lib\libc\rom\string; ..\components\sdk-ameba\soc\realtek\8711b\swlib\std_lib\libgcc\rtl8195a\include; ..\components\sdk-ameba\soc\realtek\8711b\swlib\rtl_lib; ..\components\sdk-ameba\soc\realtek\8711b\misc; ..\components\sdk-ameba\soc\realtek\8711b\misc\os; ..\components\sdk-ameba\common\mbed\api; ..\components\sdk-ameba\common\mbed\hal; ..\components\sdk-ameba\common\mbed\hal_ext; ..\components\sdk-ameba\common\mbed\targets\cmsis\rtl8711b; ..\components\sdk-ameba\common\mbed\targets\hal\rtl8711b; ..\components\sdk-ameba\common\network\coap\include; ..\components\intoyun-iot\platform\inc; ..\components\intoyun-iot\sdk\cloud\datapoint; ..\components\intoyun-iot\sdk\cloud\otaupdate; ..\components\intoyun-iot\sdk\comm\coap; ..\components\intoyun-iot\sdk\comm\coap\CoAPPacket; ..\components\intoyun-iot\sdk\comm\mqtt; ..\components\intoyun-iot\sdk\comm\mqtt\MQTTPacket; ..\components\intoyun-iot\sdk\comm-if; ..\components\intoyun-iot\sdk\config; ..\components\intoyun-iot\sdk\log; ..\components\intoyun-iot\sdk\sdk-impl; ..\components\intoyun-iot\sdk\sdk-impl\exports; ..\components\intoyun-iot\sdk\sdk-impl\imports; ..\components\intoyun-iot\sdk\security; ..\components\intoyun-iot\sdk\system; ..\components\intoyun-iot\sdk\utils\digest; ..\components\intoyun-iot\sdk\utils\misc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\main\inc; ..\components\sdk-ameba\soc\realtek\8711b\cmsis; ..\components\sdk-ameba\soc\realtek\8711b\swlib\os_dep\include; ..\components\sdk-ameba\os\freertos\freertos_v8.1.2\Source\include; ..\components\sdk-ameba\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM4F
  OBJCOPY.OOCOutputFile: application.srec
  prebuild: CSCRIPT  "..\components\sdk-ameba\soc\realtek\8711b\misc\iar_utility\common\prebuild.vbs" "$PROJ_DIR$" "1" "0x08080000"
  postbuild: CSCRIPT  "..\components\sdk-ameba\soc\realtek\8711b\misc\iar_utility\common\postbuild_img2.vbs" "$TARGET_DIR$" "$PROJ_DIR$"
  ILINK.IlinkOutputFile: application.axf
  ILINK.IlinkKeepSymbols: bootloader
  ILINK.IlinkIcfFile: image2.icf
  ILINK.IlinkExtraOptions: --pi_veneers
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group intoyun-iot/platform
    ../components/intoyun-iot/platform/src/rtl8710/: hal_dtls_interface.c hal_os_interface.c hal_tcp_interface.c hal_tls_interface.c hal_udp_interface.c
  group intoyun-iot/sdk/cloud/datapoint
    ../components/intoyun-iot/sdk/cloud/datapoint/: iotx_datapoint_api.c
  group intoyun-iot/sdk/cloud/otaupdate
    ../components/intoyun-iot/sdk/cloud/otaupdate/: iotx_ota_api.c
  group intoyun-iot/sdk/comm/coap
    ../components/intoyun-iot/sdk/comm/coap/CoAPPacket/: CoAPDeserialize.c CoAPExport.c CoAPMessage.c CoAPNetwork.c CoAPSerialize.c
    ../components/intoyun-iot/sdk/comm/coap/: iotx_ca_cert.c iotx_coap_client.c
  group intoyun-iot/sdk/comm/mqtt
    ../components/intoyun-iot/sdk/comm/mqtt/: iotx_mqtt_client.c
    ../components/intoyun-iot/sdk/comm/mqtt/MQTTPacket/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group intoyun-iot/sdk/comm-if
    ../components/intoyun-iot/sdk/comm-if/: iotx_comm_if_api.c iotx_comm_if_coap.c iotx_comm_if_mqtt.c
  group intoyun-iot/sdk/log
    ../components/intoyun-iot/sdk/log/: iotx_log_api.c
  group intoyun-iot/sdk/sdk-impl
    ../components/intoyun-iot/sdk/sdk-impl/: sdk_impl.c
  group intoyun-iot/sdk/security
    ../components/intoyun-iot/sdk/security/: iotx_crypto_api.c iotx_guider_api.c
  group intoyun-iot/sdk/system
    ../components/intoyun-iot/sdk/system/: ca.c iotx_key_api.c iotx_system_api.c iotx_timer_api.c
  group intoyun-iot/sdk/utils/digest
    ../components/intoyun-iot/sdk/utils/digest/: utils_aes.c utils_base64.c utils_cmac.c utils_hmac.c utils_md5.c utils_sha1.c
  group intoyun-iot/sdk/utils/misc
    ../components/intoyun-iot/sdk/utils/misc/: utils_cjson.c utils_common.c utils_epoch_time.c utils_httpc.c utils_list.c utils_net.c utils_timer.c
  group sdk-ameba/app/uart_adapter
    ../components/sdk-ameba/common/application/uart_adapter/: uart_adapter.c
  group sdk-ameba/cmsis
    ../components/sdk-ameba/soc/realtek/8711b/cmsis/device/: app_start.c
    ../components/sdk-ameba/soc/realtek/8711b/fwlib/ram_lib/: startup.c
  group sdk-ameba/console
    ../components/sdk-ameba/common/api/at_cmd/: atcmd_lwip.c atcmd_sys.c atcmd_wifi.c log_service.c
    ../components/sdk-ameba/soc/realtek/8711b/app/monitor/ram/: low_level_io.c monitor.c rtl_consol.c rtl_trace.c
  group sdk-ameba/lib
    ../components/sdk-ameba/soc/realtek/8711b/misc/bsp/lib/common/IAR/: lib_http.a lib_mdns.a lib_platform.a lib_rtlstd.a lib_wlan.a lib_wlan_mp.a lib_wps.a lib_xmodem.a
  group sdk-ameba/network/api
    ../components/sdk-ameba/common/api/: lwip_netconf.c
  group sdk-ameba/network/api/wifi
    ../components/sdk-ameba/common/api/wifi/: wifi_conf.c wifi_ind.c wifi_promisc.c wifi_simple_config.c wifi_util.c
  group sdk-ameba/network/api/wifi/rtw_wpa_supplicant
    ../components/sdk-ameba/common/api/wifi/rtw_wpa_supplicant/wpa_supplicant/: wifi_eap_config.c wifi_wps_config.c
  group sdk-ameba/network/app
    ../components/sdk-ameba/common/api/network/src/: ping_test.c wlan_network.c
    ../components/sdk-ameba/common/utilities/: ssl_client.c tcptest.c
  group sdk-ameba/network/googlenest
    ../components/sdk-ameba/common/application/google/: google_tls.c
  group sdk-ameba/network/http
    ../components/sdk-ameba/common/network/httpc/: httpc_tls.c
    ../components/sdk-ameba/common/network/httpd/: httpd_tls.c
  group sdk-ameba/network/lwip
    ../components/sdk-ameba/common/network/dhcp/: dhcps.c
  group sdk-ameba/network/lwip/api
    ../components/sdk-ameba/common/network/lwip/lwip_v1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group sdk-ameba/network/lwip/core
    ../components/sdk-ameba/common/network/lwip/lwip_v1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group sdk-ameba/network/lwip/core/ipv4
    ../components/sdk-ameba/common/network/lwip/lwip_v1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group sdk-ameba/network/lwip/netif
    ../components/sdk-ameba/common/network/lwip/lwip_v1.4.1/src/netif/: etharp.c
  group sdk-ameba/network/lwip/port
    ../components/sdk-ameba/common/network/lwip/lwip_v1.4.1/port/realtek/freertos/: ethernetif.c sys_arch.c
    ../components/sdk-ameba/common/drivers/wlan/realtek/src/osdep/: lwip_intf.c
  group sdk-ameba/network/mdns
    ../components/sdk-ameba/common/network/mDNS/: mDNSPlatform.c
  group sdk-ameba/network/polarssl/polarssl
    ../components/sdk-ameba/common/network/ssl/polarssl-1.3.8/library/: aesni.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c debug.c ecp_ram.c entropy.c entropy_poll.c error.c gcm.c havege.c md2.c md4.c memory_buffer_alloc.c net.c padlock.c pbkdf2.c pkcs11.c pkcs12.c pkcs5.c pkparse.c platform.c ripemd160.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_srv.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group sdk-ameba/network/polarssl/ssl_ram_map
    ../components/sdk-ameba/common/network/ssl/ssl_ram_map/: ssl_ram_map.c
  group sdk-ameba/os/freertos
    ../components/sdk-ameba/os/freertos/: cmsis_os.c freertos_service.c
    ../components/sdk-ameba/os/freertos/freertos_v8.1.2/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group sdk-ameba/os/freertos/portable
    ../components/sdk-ameba/os/freertos/freertos_v8.1.2/Source/portable/MemMang/: heap_5.c
    ../components/sdk-ameba/os/freertos/freertos_v8.1.2/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group sdk-ameba/os/osdep
    ../components/sdk-ameba/os/os_dep/: device_lock.c osdep_service.c
  group sdk-ameba/peripheral/api
    ../components/sdk-ameba/common/mbed/targets/hal/rtl8711b/: analogin_api.c dma_api.c efuse_api.c flash_api.c gpio_api.c gpio_irq_api.c i2c_api.c i2s_api.c nfc_api.c pinmap.c pinmap_common.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c sys_api.c timer_api.c us_ticker.c us_ticker_api.c wait_api.c wdt_api.c
  group sdk-ameba/peripheral/rtl8710b
    ../components/sdk-ameba/soc/realtek/8711b/fwlib/ram_lib/: rtl8710b_dsleepcfg.c rtl8710b_dstandbycfg.c rtl8710b_intfcfg.c rtl8710b_pinmapcfg.c rtl8710b_sleepcfg.c
    ../components/sdk-ameba/soc/realtek/8711b/misc/: rtl8710b_ota.c
  group sdk-ameba/peripheral/wlan
    ../components/sdk-ameba/common/drivers/wlan/realtek/src/core/option/: rtw_opt_power_by_rate.c rtw_opt_power_limit.c rtw_opt_skbuf.c
  group sdk-ameba/utilities
    ../components/sdk-ameba/common/application/xmodem/: uart_fw_update.c
    ../components/sdk-ameba/common/utilities/: uart_socket.c webserver.c xml.c
  group sdk-ameba/utilities/wigadget
    ../components/sdk-ameba/common/application/wigadget/: cloud_link.c shtc1.c wigadget.c
  group user
    ../main/src/: ota_update.c project.c user_main.c
